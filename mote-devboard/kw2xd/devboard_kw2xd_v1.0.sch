File: mote-devboard/kw2xd/devboard_kw2xd_v1.0.sch (EAGLE design)
At the start: 11 parts, among them Q3 RED

Commit message: - Add .brd board layout file
Parts:
- renumbered U$1 to MODULE1
